# Keil uVision project Project.uvproj, settings and files
target GD32C10X (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32C103VB GigaDevice
  cpu: IRAM(0x20000000-0x20007FFF)IROM(0x08000000-0x0801FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32C10X,GD32C103V_EVAL
  c include: ..\;..\..\Firmware\CMSIS;..\..\Firmware\CMSIS\GD\GD32C10x\Include;..\..\Firmware\GD32C10x_standard_peripheral\Include;..\..\Utilities;..\..\Utilities\LCD_Commom
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../: main.c systick.c gd32c10x_it.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32C10x/Source/: system_gd32c10x.c
  group Peripherals
    ../../Firmware/GD32C10x_standard_peripheral/Source/: gd32c10x_adc.c gd32c10x_bkp.c gd32c10x_can.c gd32c10x_crc.c gd32c10x_ctc.c gd32c10x_dac.c gd32c10x_dbg.c gd32c10x_dma.c gd32c10x_exmc.c gd32c10x_exti.c gd32c10x_fmc.c gd32c10x_fwdgt.c gd32c10x_gpio.c gd32c10x_i2c.c gd32c10x_misc.c gd32c10x_pmu.c gd32c10x_rcu.c gd32c10x_rtc.c gd32c10x_spi.c gd32c10x_timer.c gd32c10x_usart.c gd32c10x_wwdgt.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32C10x/Source/ARM/: startup_gd32c10x.s
  group Utilities
    ../../Utilities/: gd32c10x_eval.c gd32c10x_lcd_eval.c
    ../../Utilities/LCD_Commom/: lcd_font.c
  group Doc
    ../: readme.txt
